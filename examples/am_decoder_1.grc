<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>am_audio_decoder_1</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>signal_freq</value></param>
<param><key>value</key><value>127000000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>127000000</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>127000001</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>signal_freq_0</value></param>
<param><key>value</key><value>signal_freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>signal_freq-samp_rate/2</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>signal_freq+samp_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>signal_freq_1</value></param>
<param><key>value</key><value>signal_freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>signal_freq - samp_rate/2</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>signal_freq+samp_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>signal_freq_2</value></param>
<param><key>value</key><value>signal_freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>signal_freq-samp_rate/2</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>signal_freq+samp_rate/2</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>signal_freq_1 - signal_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>signal_freq_0 - signal_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>signal_freq_2 - signal_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>eewls_am_audio_decoder</key>
<param><key>id</key><value>eewls_am_audio_decoder_0_0</value></param>
<param><key>audio_gain</key><value>0.5</value></param>
<param><key>audio_low_pass_cutoff</key><value>5000</value></param>
<param><key>audio_low_pass_trans</key><value>1000</value></param>
<param><key>audio_freq</key><value>48000</value></param>
<param><key>signal_low_pass_cutoff</key><value>50000</value></param>
<param><key>sign_freq</key><value>samp_rate</value></param>
<param><key>signal_low_pass_trans</key><value>5000</value></param>
<param><key>use_dc_blocker</key><value>1</value></param>
</block>
<block>
<key>eewls_am_audio_decoder</key>
<param><key>id</key><value>eewls_am_audio_decoder_0_0_0</value></param>
<param><key>audio_gain</key><value>0.5</value></param>
<param><key>audio_low_pass_cutoff</key><value>5000</value></param>
<param><key>audio_low_pass_trans</key><value>1000</value></param>
<param><key>audio_freq</key><value>48000</value></param>
<param><key>signal_low_pass_cutoff</key><value>50000</value></param>
<param><key>sign_freq</key><value>samp_rate</value></param>
<param><key>signal_low_pass_trans</key><value>5000</value></param>
<param><key>use_dc_blocker</key><value>1</value></param>
</block>
<block>
<key>eewls_am_audio_decoder</key>
<param><key>id</key><value>eewls_am_audio_decoder_0_0_1</value></param>
<param><key>audio_gain</key><value>0.5</value></param>
<param><key>audio_low_pass_cutoff</key><value>5000</value></param>
<param><key>audio_low_pass_trans</key><value>1000</value></param>
<param><key>audio_freq</key><value>48000</value></param>
<param><key>signal_low_pass_cutoff</key><value>50000</value></param>
<param><key>sign_freq</key><value>samp_rate</value></param>
<param><key>signal_low_pass_trans</key><value>5000</value></param>
<param><key>use_dc_blocker</key><value>1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>signal_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtl2832_source</key>
<param><key>id</key><value>rtl_source</value></param>
<param><key>auto_gain_mode</key><value>True</value></param>
<param><key>bandwidth</key><value>100000</value></param>
<param><key>buf_level</key><value>0</value></param>
<param><key>buf_mul</key><value>0</value></param>
<param><key>xtal_freq</key><value>0</value></param>
<param><key>tuner_name</key><value>r820t</value></param>
<param><key>usb_pid</key><value>0x0</value></param>
<param><key>usb_vid</key><value>0x0</value></param>
<param><key>fir_coeffs</key><value>[]</value></param>
<param><key>frequency</key><value>signal_freq</value></param>
<param><key>gain_mode</key><value></value></param>
<param><key>gain</key><value>200</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status_out</key><value>False</value></param>
<param><key>relative_gain</key><value>True</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>use_buffer</key><value>True</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>read_length</key><value>0</value></param>
<param><key>xfer_timeout</key><value>0</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>eewls_am_audio_decoder_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>eewls_am_audio_decoder_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0</source_block_id><sink_block_id>eewls_am_audio_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eewls_am_audio_decoder_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eewls_am_audio_decoder_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>eewls_am_audio_decoder_0_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rtl_source</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl_source</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl_source</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl_source</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
