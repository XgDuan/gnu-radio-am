<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_decoder_system</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>channel_freq</value></param>
<param><key>value</key><value>103900000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>78000000</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>108000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>low_pass_cutoff</value></param>
<param><key>value</key><value>75000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>100000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>low_pass_trans</value></param>
<param><key>value</key><value>5000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>5</value></param>
<param><key>quad_rate</key><value>500000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>auto_gain_low_pass_filter</key>
<param><key>id</key><value>auto_gain_low_pass_filter_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>cutoff_freq</key><value>low_pass_cutoff</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain_update</key><value>0.95</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>autogain</key><value>0.5</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>low_pass_trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate/8</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"ors"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>50</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rtl2832_source</key>
<param><key>id</key><value>rtl2832_source_0</value></param>
<param><key>auto_gain_mode</key><value>True</value></param>
<param><key>bandwidth</key><value>0</value></param>
<param><key>buf_level</key><value>0</value></param>
<param><key>buf_mul</key><value>0</value></param>
<param><key>xtal_freq</key><value>0</value></param>
<param><key>tuner_name</key><value>r820t</value></param>
<param><key>usb_pid</key><value>0x0</value></param>
<param><key>usb_vid</key><value>0x0</value></param>
<param><key>fir_coeffs</key><value>[]</value></param>
<param><key>frequency</key><value>channel_freq</value></param>
<param><key>gain_mode</key><value></value></param>
<param><key>gain</key><value>20</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status_out</key><value>False</value></param>
<param><key>relative_gain</key><value>True</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>use_buffer</key><value>True</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>read_length</key><value>0</value></param>
<param><key>xfer_timeout</key><value>0</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>auto_gain_low_pass_filter_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>auto_gain_low_pass_filter_0</source_block_id><sink_block_id>qtgui_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>auto_gain_low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
